# PetaLinux 2019.1 builds petalinux-user-image (not petalinux-image-full).
IMAGE_INSTALL_append = " canfd-server"
